Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: j200_f_fixed_bollard.ifc
Time: 2016-06-15T06:09:37
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2015
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcProxy, J200 F Fixed bollard
ePset_BIMobject_Lena - COLOR: Painted Steel; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): J200 F Fixed bollard; SKU (BO_prodsku): FAAC-J200-F; ManufacturName (BO_Manufac): FAAC; ProductFamily (BO_prodfam): AUTOMATION; ProductGroup (BO_prodgroup): TRAFFIC BOLLARD; ManufacturCountry (BO_mancont): Italy; DesignCountry (BO_designcont): Italy; PublishDate (BO_publisdat): 5/9/2016; EditionNumber (BO_edinum): 1; Width (BO_width): 400; Height (BO_height): 600; Depth (BO_depth): 500; Weight (BO_weight): 35; QR (BO_boqrurl): http://bimobject.com/faac/product/FAAC-J200-F; ProductDataUrl (BO_prodaturl): bimobject.com/faac/product/FAAC-J200-F; InstallationInstructions (BO_montins): http://faac.international/products/traffic-bollards/controlli-accessi-dissuasori/#!/nav/FAAC_J200F_BOLLARDS; ProductCertification (BO_prodcert): http://faac.international/products/traffic-bollards/controlli-accessi-dissuasori/#!/nav/FAAC_J200F_BOLLARDS; TechnicalDescription (BO_techcert): http://faac.international/products/traffic-bollards/controlli-accessi-dissuasori/#!/nav/FAAC_J200F_BOLLARDS; InstructionVideo (BO_youtube): https://vimeo.com/channels/faacproducts/80985662; MaterialMain (BO_mainmat): Steel; MaterialSecondary (BO_secmat): Stainless steel; BimObjectCategory (BO_bocat): Other; IfcClassification (BO_ifcclas): Object; Uniclass2015Code (BO_uniclass2015_code): Pr_20_76_08_51; Uniclass2015Description (BO_uniclass2015_desc): Metal bollards; OmniClassCode (BO_omniclass_code): 23-11 29 35; OmniClassDescription (BO_omniclass_name): Bollards; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
